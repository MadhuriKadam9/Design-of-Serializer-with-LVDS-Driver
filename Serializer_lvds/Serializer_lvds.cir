* D:\Serializer_Lvds_dvr\Serializer_lvds\Serializer_lvds.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 03/10/22 15:00:26

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U2  Net-_U10-Pad7_ Net-_U10-Pad8_ Net-_U10-Pad9_ Net-_U10-Pad10_ Net-_U10-Pad11_ Net-_U10-Pad12_ Net-_U11-Pad7_ Net-_U11-Pad8_ Net-_U11-Pad9_ Net-_U11-Pad10_ Net-_U11-Pad11_ Net-_U11-Pad12_ DATA_SR madhuri_piso
U13  DATA_SR DIN DIN_Bar madhuri_buffer
U17  DIN DIN_Bar Net-_U17-Pad3_ Net-_U17-Pad4_ dac_bridge_2
U10  CLK LOAD I9 GND I7 GND Net-_U10-Pad7_ Net-_U10-Pad8_ Net-_U10-Pad9_ Net-_U10-Pad10_ Net-_U10-Pad11_ Net-_U10-Pad12_ adc_bridge_6
U11  I5 GND I3 I2 I1 I0 Net-_U11-Pad7_ Net-_U11-Pad8_ Net-_U11-Pad9_ Net-_U11-Pad10_ Net-_U11-Pad11_ Net-_U11-Pad12_ adc_bridge_6
v10  Net-_X1-Pad1_ GND DC
v11  Net-_X1-Pad2_ GND DC
v1  CLK GND pulse
v2  LOAD GND pulse
v5  I9 GND pulse
v6  I7 GND pulse
v7  I5 GND pulse
v8  I3 GND pulse
v9  I2 GND pulse
v3  I1 GND pulse
v4  I0 GND pulse
U3  CLK plot_v1
U5  LOAD plot_v1
U7  I9 plot_v1
U8  I7 plot_v1
U1  I0 plot_v1
U4  I1 plot_v1
U6  I2 plot_v1
U9  I3 plot_v1
U12  I5 plot_v1
U14  DATA_SR plot_v1
U15  DIN plot_v1
U16  DIN_Bar plot_v1
U18  Voa plot_v1
U19  Vob plot_v1
X1  Net-_X1-Pad1_ Net-_X1-Pad2_ Net-_U17-Pad3_ Net-_U17-Pad4_ Voa Vocm Vob LVDS_Drvr
U20  Vocm plot_v1

.end
